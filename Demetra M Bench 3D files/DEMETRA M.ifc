Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T14:49:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 14:49:11 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{5971C386-00FE-4EFD-82BF-B83291019EC7}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 14:49:10 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 14:49:11 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 14:49:11 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR164 - WITHOUT LEVELLING - VERDE ALPI, Panca DEMETRA M:0PAAR164 - WITHOUT LEVELLING - VERDE ALPI:174811
In: 0 - Piano Terra
Type - Material: VERDE ALPI
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca DEMETRA M
Type - Dati identità - BIM Name: DEMETRA M SENZA LIVELLAMENTO; BIM Object Type: PANCHINE - BENCHES; Code: 0PAAR164; Designer: BELLITALIA DESIGN; Family Name: DEMETRA; Nome del tipo: 0PAAR164 - WITHOUT LEVELLING - VERDE ALPI; URL Eng: https://www.bellitalia.net/en/products/benches/demetra-m/; URL Ita: https://www.bellitalia.net/prodotti/panchine/demetra-m/
Type - Dimensioni - Dimensions: 600 mm x 600 mm x 480 mm
Type - Generale - Accessori: Supplemento per una striscia led e alimentatore; Accessories: Supplement for a led strip and power supply; Descrizione Tecnica Famiglia: "Panca lineare modulare mod. “DEMETRA M” singola costituita da una seduta monolitica. La pianta planimetrica corrisponde ad un quadrato, la panca è perfettamente associabile alla famiglia ""DEMETRA"" per creare composizioni a piacere."; Descrizione Tecnica per Codice: PANCA DEMETRA M SENZA LIVELLAMENTO IN VERDE ALPI SABBIATO CON PIANO DI SEDUTA BOCCIARDATO VERNICIATURA ANTI-DEGRADO; Fissaggio: Appoggio; Fixings: Freestanding; Technical Description Family: "Modular linear bench mod. ""DEMETRA M"" single consisting of a monolithic seat. The planimetric plan corresponds to a square, the bench can be perfectly associated with the ""DEMETRA"" family to create compositions as desired."; Technical Description for Article: DEMETRA M WITHOUT LEVELLING SYSTEM BENCH IN GREEN ALPS SANDBLASTED WITH BUSH-HAMMERED SEAT SURFACE ANTI-DECAY VARNISH
Type - Materiali e finiture - Materiale Principale: Pietre Preziose Ricostituite Verde Alpi; Materiale Secondario: Pietre Preziose Ricostituite; MATERIALE SEDUTA: VERDE ALPI; Primary Material: Green Alps Reconstituted Precious Stones; Secondary Material: Reconstituted Precious Stone
Type - Meccanica - Weight ( kg): 396 Kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR164 - WITHOUT LEVELLING - VERDE ALPI
Altro - Famiglia: Panca DEMETRA M: 0PAAR164 - WITHOUT LEVELLING - VERDE ALPI; Famiglia e tipo: Panca DEMETRA M: 0PAAR164 - WITHOUT LEVELLING - VERDE ALPI; ID tipo: Panca DEMETRA M: 0PAAR164 - WITHOUT LEVELLING - VERDE ALPI; Tipo: Panca DEMETRA M: 0PAAR164 - WITHOUT LEVELLING - VERDE ALPI
Dimensioni - Area: 1.26614 m2; Volume: 0.160813 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
